# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H750xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\.Library; ..\User; ..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\Drivers\CMSIS\Device\ST\STM32H7xx\Source\iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32H7xx/Source/: system_stm32h7xx.c
  group HAL_Library
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c
  group IAR_Standard
    ../Drivers/CMSIS/Device/ST/STM32H7xx/Source/iar/: startup_stm32h750xx.s
  group USER
    ../.Library/: adc_config.c dac_config.c delay.c Lib_iir_filter.c tim_config.c
    ../User/: main.c
